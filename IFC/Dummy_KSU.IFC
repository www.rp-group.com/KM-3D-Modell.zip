Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Dummy_KSU.IFC
Time: 2015-02-10T09:50:15
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
